Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 4d927080-cf7e-4d51-a2e1-0c9e701c96fb, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T22:29:39+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12911750_D_KM8560FR:26I85600_D_12911750_KM8560FR, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 626 mm; Height: 45 mm; Depth: 526 mm
Material: z_Miele_Design_Steel_Chrom, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - Reference: 26I85600_D_12911750_KM8560FR; sets with these values: 2
